<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>WIFI_OFDM_TX</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Frequency</value></param>
<param><key>value</key><value>2.406e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RxGain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>400</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>TxGain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_Tx</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate_Rx</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>IFFT_V_IFFT_ff</key>
<param><key>id</key><value>IFFT_V_IFFT_ff_0</value></param>
<param><key>IFFTSize</key><value>64</value></param>
</block>
<block>
<key>InBlock_vamsi_src_c</key>
<param><key>id</key><value>InBlock_vamsi_src_c_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>InDatlen</key><value>40</value></param>
</block>
<block>
<key>OFDMPreamble_vamsi_OFDMPreamble_ff</key>
<param><key>id</key><value>OFDMPreamble_vamsi_OFDMPreamble_ff_0</value></param>
<param><key>Indatalen</key><value>80</value></param>
</block>
<block>
<key>OFDM_Cyclic_Prefix_vamsi_OFDMCP_ff</key>
<param><key>id</key><value>OFDM_Cyclic_Prefix_vamsi_OFDMCP_ff_0</value></param>
<param><key>CPLen</key><value>16</value></param>
<param><key>InputLen</key><value>64</value></param>
</block>
<block>
<key>QPSK_mod_Vamsi_QPSK_mod_cf</key>
<param><key>id</key><value>QPSK_mod_Vamsi_QPSK_mod_cf_0</value></param>
<param><key>Inputlen</key><value>96</value></param>
</block>
<block>
<key>Viterbi_Encoder_Viterbi_vamsi_cc</key>
<param><key>id</key><value>Viterbi_Encoder_Viterbi_vamsi_cc_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/chagari/Work/GNURadio/OverAir-Test/TXChain-Dumpdata/TXdataDump.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/chagari/Work/GNURadio/OverAir-Test/GRC/short_long_pream.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/intel-nuc/My-Blocks/GRC/input.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/chagari/Work/GNURadio/OverAir-Test/TXChain-Dumpdata/TXdataDump.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>my_interleaver_vamsi_interleaver_cc</key>
<param><key>id</key><value>my_interleaver_vamsi_interleaver_cc_0</value></param>
<param><key>Ninputs</key><value>96</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>1e6</value></param>
<param><key>fc</key><value>2.406e09</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1</value></param>
<param><key>bw</key><value>1e6</value></param>
<param><key>fc</key><value>Frequency</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_2</value></param>
<param><key>bw</key><value>samp_rate_Tx</value></param>
<param><key>fc</key><value>Frequency</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>sourceblock_vamsi_sourceblk_c</key>
<param><key>id</key><value>sourceblock_vamsi_sourceblk_c_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>center_freq0</key><value>Frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>TxGain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate_Tx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>center_freq0</key><value>Frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>RxGain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>sample_rate_Rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>vamsi_scram_scram_cc</key>
<param><key>id</key><value>vamsi_scram_scram_cc_1</value></param>
</block>
<connection><source_block_id>IFFT_V_IFFT_ff_0</source_block_id><sink_block_id>OFDM_Cyclic_Prefix_vamsi_OFDMCP_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>InBlock_vamsi_src_c_0</source_block_id><sink_block_id>vamsi_scram_scram_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>OFDMPreamble_vamsi_OFDMPreamble_ff_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>OFDMPreamble_vamsi_OFDMPreamble_ff_0</source_block_id><sink_block_id>qtgui_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>OFDM_Cyclic_Prefix_vamsi_OFDMCP_ff_0</source_block_id><sink_block_id>OFDMPreamble_vamsi_OFDMPreamble_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>QPSK_mod_Vamsi_QPSK_mod_cf_0</source_block_id><sink_block_id>IFFT_V_IFFT_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Viterbi_Encoder_Viterbi_vamsi_cc_0</source_block_id><sink_block_id>my_interleaver_vamsi_interleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>vamsi_scram_scram_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_interleaver_vamsi_interleaver_cc_0</source_block_id><sink_block_id>QPSK_mod_Vamsi_QPSK_mod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sourceblock_vamsi_sourceblk_c_0</source_block_id><sink_block_id>vamsi_scram_scram_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vamsi_scram_scram_cc_1</source_block_id><sink_block_id>Viterbi_Encoder_Viterbi_vamsi_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
